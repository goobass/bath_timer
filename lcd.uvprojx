# Keil uVision project lcd.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: LPC1114FN28/102 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lcd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -std=c11
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./: Board_I2c.h Board_LED.h Board_Remote.h Board_Port.h Board_CLKOUT.c Board_I2c.c Board_Timer.c Board_Uart.c LED_MCB11C14.c main.c system_LPC11xx.c Board_CLKOUT.h Board_Timer.h Board_Uart.h cmsis_armclang.h cmsis_compiler.h cmsis_os.h cmsis_version.h core_cm0.h LPC11xx.h startup_LPC11xx.s Buttons_MCB11C14.c Board_Buttons.h
